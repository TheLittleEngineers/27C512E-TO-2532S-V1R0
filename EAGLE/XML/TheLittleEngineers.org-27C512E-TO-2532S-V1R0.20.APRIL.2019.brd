# Repository TheLittleEngineers/27C512E-TO-2532S-V1R0

File README.md:

# 27C512E-TO-2532S-V1R0
(Deprecated - See below for link to new version)
This product, TheLittleEngineers.org-27C512E-TO-2532S-V1R0.20.APRIL.2019, is intended to allow a 27512 or 27C512 EPROM to be placed into a TMS2532 EPROM socket. The 27512 is divided into 16 banks of 4Kbytes via the four jumpers at the bottom of the socket. https://github.com/TheLittleEngineers/27C512E-TO-2532S-V1R0

This project is licensed under a Creative Commons Attribution-ShareAlike 4.0 International (CC BY-SA 4.0) License: https://creativecommons.org/licenses/by-sa/4.0/

OshPark: https://oshpark.com/shared_projects/5EPozkYK

Please note: This is derived from an original design by "Little" John Eric and/or his father "Big" John Robert (J.R.) by "Uncle" Robert Allen. It should be thoroughly scrutinized and verified prior to actual use of any kind. DISCLAIMER: The following article is provided for informational purposes only. Any attempt to modify your computer without the proper skills to do so may void your computer. Any attempt to modify your computer without unplugging it first may void you. This Information is provided "as-is" with no guarantee of fitness for any purpose, either explicit or implied. We disclaim any and all responsibility for losses incurred through the use of this information. By using this information, you are deemed to have accepted these conditions of use, and you agree NOT to sue us. CLARIFICATION: The above disclaimer states as plainly as possible that if you decide to make use of any of the information contained within this document that you do so at your own risk. Designing hardware for the CoCo (ColorComputer), Dragon D32, D64, D200 and other vintage hardware is a hobby of ours and is not motivated by any desire of profits. As this is a not for profit venture, obviously we can't afford not to disclaim the use of this information.

 PLEASE NOTE: THIS VERSION HAS NOT YET BEEN TESTED. 

IMPORTANT: I have created an update to this product and the NEW repository resides at this url:
https://github.com/TheLittleEngineers/27C512E-TO-2532S-V1R1.20.APRIL.2019

This update was made due to the fact that I was not very pleased with the initial Printed Circuit Boards that resulted from this, the original design. Although functional, the production of the Printed Circuit Boards was inconsistent between different manufacturers. This was due to a problem in the dimension layer of this original design and so I have created the new design to eliminate the inconsistencies.

The NEW version should provide much better results. Please refer to the new version: https://github.com/TheLittleEngineers/27C512E-TO-2532S-V1R1.20.APRIL.2019

## EAGLE design EAGLE/XML/TheLittleEngineers.org-27C512E-TO-2532S-V1R0.20.APRIL.2019.brd

Parts:
A1, A2, A3, A4: HEADER-1X03-STAGGERED-S; HEADER-1X03-STAGGERED
IC1: 2532-NO; DIL24-6-NO-OUTLINE
IC2: 27C512D-NO; DIL28-6-NO-OUTLINE

Connections:
!CE: IC1.20 (PD/!PGM!/!CE), IC2.20 (!CE), IC2.22 (!OE!/VPP)
A0: IC1.8 (A0), IC2.10 (A0)
A1: IC1.7 (A1), IC2.9 (A1)
A2: IC1.6 (A2), IC2.8 (A2)
A3: IC1.5 (A3), IC2.7 (A3)
A4: IC1.4 (A4), IC2.6 (A4)
A5: IC1.3 (A5), IC2.5 (A5)
A6: IC1.2 (A6), IC2.4 (A6)
A7: IC1.1 (A7), IC2.3 (A7)
A8: IC1.23 (A8), IC2.25 (A8)
A9: IC1.22 (A9), IC2.24 (A9)
A10: IC1.19 (A10), IC2.21 (A10)
A11: IC1.18 (A11), IC2.23 (A11)
A12: A1.2, IC2.2 (A12)
A13: A2.2, IC2.26 (A13)
A14: A3.2, IC2.27 (A14)
A15: A4.2, IC2.1 (A15)
D0: IC1.9 (Q1), IC2.11 (O0)
D1: IC1.10 (Q2), IC2.12 (O1)
D2: IC1.11 (Q3), IC2.13 (O2)
D3: IC1.13 (Q4), IC2.15 (O3)
D4: IC1.14 (Q5), IC2.16 (O4)
D5: IC1.15 (Q6), IC2.17 (O5)
D6: IC1.16 (Q7), IC2.18 (O6)
D7: IC1.17 (Q8), IC2.19 (O7)
GND: A1.3, A2.3, A3.3, A4.3, IC1.12 (-V-), IC2.14 (-V-)
VCC: A1.1, A2.1, A3.1, A4.1, IC1.21 (VPP), IC1.24 (+V+), IC2.28 (+V+)

Board: 2 copper layers, 18.0 x 44.1 mm, 9 parts (2 on the bottom side), 27 nets.

Other parts of the board:
U$1: OUTLINE
U$2: TLE-LOGO-I
U$3: TLE-LOGO-F

## Commit log

2019-07-31 Added DIRectories for improved appearance and workflow
2019-08-01 Maintenance

Notices in the files:
parts and their libraries:
27C512E-TO-2532S-V1R0.20.APRIL.2019-JOHN: Copyright ©07 Jan 2013, by:
Robert "The R.A.T." Allen Turner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
TheLittleEngineers.org-27C512E-TO-2532S-: ©2019 Robert Allen Turner, ALL RIGHTS RESERVED.
